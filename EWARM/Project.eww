<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HOMEWORK_OV2640_BUILDUP.ewp</path>
  </project>
  <batchBuild />
</workspace>
